Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2015-07-30T16:16:08
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130709_2115(x64) - Exporter 3.12.0.0 - Alternate UI 2.12.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Jul 30 16:16:08 2015* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{60FB53B6-4CDB-41D4-A357-226194284E5D}\ifc* Database version: 5507* Database creation date: Thu Jul 30 16:16:07 2015* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Jul 30 16:16:08 2015* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Jul 30 16:16:08 2015* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: NBS_PineappleContracts_DomesticChairs_BodenBeanBag, NBS_PineappleContracts_DmstcChrs_BodenBeanBag:NBS_PineappleContracts_DomesticChairs_BodenBeanBag:279065
In: Level 0
Type - Classification: Pr_40_50_12_22 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_PineappleContracts_DomesticChairs_BodenBeanBag; ManufacturerName: Pineapple Contracts; ManufacturerURL: www.pineapplecontracts.com; NBSCertification: www.nationalbimlibrary.com/cert/hqaduyev; NBSDescription: Domestic chairs; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-20/365; NBSTypeID: n/a; ProductInformation: www.pineapplecontracts.com/userfiles/file/Pineapple-main-brochure-2014.pdf; Revision: n/a; Version: 2; Uniclass2015Title: Dining chairs; Uniclass2015Code: Pr_40_50_12_22; Uniclass2015Version: Products v1.5
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: Pr_40_50_12_22:Dining chairs; CodePerformance: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Fully stitched with no zips to prevent tampering; Finish: n/a; Grade: n/a; Manufacturer: www.pineapplecontracts.com; Material: n/a; ModelNumber: ABO1-00-A; ModelReference: Boden Bean Bag; Name: DomesticChairs_BodenBeanBag_PineappleContracts; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Guarantee against manufacturing faults; WarrantyDurationLabor: n/a; WarrantyDurationParts: 7; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_FurnitureTypeCommon - Description: Bean bag; IsBuiltIn: no; MainColor: n/a; NominalDepth: 0 mm; NominalHeight: 0 mm; NominalLength: 0 mm
Type - Pset_FurnitureTypeChair - HighestSeatingHeight: 0 mm; LowestSeatingHeight: 0 mm; SeatingHeight: 0 mm
Type - NBS_Data - EnvironmentalProductDeclaration: n/a; FabricFireRating: Source 5 (all fabrics); FabricOptions: A wide choice of fabrics are available
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
